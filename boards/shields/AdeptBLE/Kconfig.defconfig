## boards/shields/AdeptBLE/Kconfig.defconfig
```kconfig
if SHIELD_ADEPTBLE

config ZMK_KEYBOARD_NAME
    default "RedPloopy"

endif

config SPI
	default y
```
